// vga_gfx.h
// Consolidated graphics + banner header.
// Replaces vga_text.h and vga_text_render.h now that text mode is removed.
//
// Provides:
//   - 8x12 font, draw_char / draw_string / fill_rect
//   - Ticker buffer  (ticker_push / ticker_get / ticker_init)
//   - Scrolling banner for game mode  (draw_banner_tick)
//   - wait_for_blanking()

#ifndef VGA_GFX_H
#define VGA_GFX_H

#include <stdint.h>

// Forward declarations (defined in vga.c)
extern void write_pixel(unsigned int addr, uint16_t color);
extern void fps_tick(void);

extern volatile int screen_busy;

// =========================================================================
// Screen constants
// =========================================================================
#define FB_WIDTH   320
#define FB_HEIGHT  240

// =========================================================================
// Font  —  8 × 12 bitmap, printable ASCII starting at 0x20 (space)
// =========================================================================
#define FONT_W  8
#define FONT_H  12

static const uint8_t font8x12[][FONT_H] = {
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // space
    {0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x00,0x18,0x18,0x00,0x00}, // !
    {0x6C,0x6C,0x6C,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // "
    {0x36,0x36,0x7F,0x36,0x36,0x36,0x7F,0x36,0x36,0x36,0x00,0x00}, // #
    {0x18,0x3E,0x60,0x60,0x3C,0x06,0x06,0x7C,0x18,0x18,0x00,0x00}, // $
    {0x00,0x63,0x66,0x0C,0x18,0x30,0x66,0x63,0x00,0x00,0x00,0x00}, // %
    {0x1C,0x36,0x36,0x1C,0x3B,0x6E,0x66,0x3B,0x00,0x00,0x00,0x00}, // &
    {0x18,0x18,0x18,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // '
    {0x0C,0x18,0x30,0x30,0x30,0x30,0x30,0x18,0x0C,0x00,0x00,0x00}, // (
    {0x30,0x18,0x0C,0x0C,0x0C,0x0C,0x0C,0x18,0x30,0x00,0x00,0x00}, // )
    {0x00,0x66,0x3C,0xFF,0x3C,0x66,0x00,0x00,0x00,0x00,0x00,0x00}, // *
    {0x00,0x18,0x18,0x7E,0x18,0x18,0x00,0x00,0x00,0x00,0x00,0x00}, // +
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x30,0x00,0x00}, // ,
    {0x00,0x00,0x00,0x7E,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // -
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x00}, // .
    {0x06,0x06,0x0C,0x0C,0x18,0x18,0x30,0x30,0x60,0x60,0x00,0x00}, // /
    {0x3C,0x66,0x6E,0x7E,0x76,0x66,0x66,0x3C,0x00,0x00,0x00,0x00}, // 0
    {0x18,0x38,0x18,0x18,0x18,0x18,0x18,0x7E,0x00,0x00,0x00,0x00}, // 1
    {0x3C,0x66,0x06,0x0C,0x18,0x30,0x60,0x7E,0x00,0x00,0x00,0x00}, // 2
    {0x3C,0x66,0x06,0x1C,0x06,0x06,0x66,0x3C,0x00,0x00,0x00,0x00}, // 3
    {0x0C,0x1C,0x3C,0x6C,0x7E,0x0C,0x0C,0x0C,0x00,0x00,0x00,0x00}, // 4
    {0x7E,0x60,0x60,0x7C,0x06,0x06,0x66,0x3C,0x00,0x00,0x00,0x00}, // 5
    {0x1C,0x30,0x60,0x7C,0x66,0x66,0x66,0x3C,0x00,0x00,0x00,0x00}, // 6
    {0x7E,0x06,0x0C,0x18,0x30,0x30,0x30,0x30,0x00,0x00,0x00,0x00}, // 7
    {0x3C,0x66,0x66,0x3C,0x66,0x66,0x66,0x3C,0x00,0x00,0x00,0x00}, // 8
    {0x3C,0x66,0x66,0x3E,0x06,0x0C,0x18,0x70,0x00,0x00,0x00,0x00}, // 9
    {0x00,0x18,0x18,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x00,0x00}, // :
    {0x00,0x18,0x18,0x00,0x00,0x18,0x18,0x30,0x00,0x00,0x00,0x00}, // ;
    {0x0C,0x18,0x30,0x60,0x30,0x18,0x0C,0x00,0x00,0x00,0x00,0x00}, // <
    {0x00,0x00,0x7E,0x00,0x7E,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // =
    {0x30,0x18,0x0C,0x06,0x0C,0x18,0x30,0x00,0x00,0x00,0x00,0x00}, // >
    {0x3C,0x66,0x06,0x0C,0x18,0x00,0x18,0x18,0x00,0x00,0x00,0x00}, // ?
    {0x3C,0x66,0x6E,0x6A,0x6E,0x60,0x62,0x3C,0x00,0x00,0x00,0x00}, // @
    {0x18,0x3C,0x66,0x66,0x7E,0x66,0x66,0x66,0x00,0x00,0x00,0x00}, // A
    {0x7C,0x66,0x66,0x7C,0x66,0x66,0x66,0x7C,0x00,0x00,0x00,0x00}, // B
    {0x3C,0x66,0x60,0x60,0x60,0x60,0x66,0x3C,0x00,0x00,0x00,0x00}, // C
    {0x78,0x6C,0x66,0x66,0x66,0x66,0x6C,0x78,0x00,0x00,0x00,0x00}, // D
    {0x7E,0x60,0x60,0x7C,0x60,0x60,0x60,0x7E,0x00,0x00,0x00,0x00}, // E
    {0x7E,0x60,0x60,0x7C,0x60,0x60,0x60,0x60,0x00,0x00,0x00,0x00}, // F
    {0x3C,0x66,0x60,0x60,0x6E,0x66,0x66,0x3C,0x00,0x00,0x00,0x00}, // G
    {0x66,0x66,0x66,0x7E,0x66,0x66,0x66,0x66,0x00,0x00,0x00,0x00}, // H
    {0x7E,0x18,0x18,0x18,0x18,0x18,0x18,0x7E,0x00,0x00,0x00,0x00}, // I
    {0x06,0x06,0x06,0x06,0x06,0x06,0x66,0x3C,0x00,0x00,0x00,0x00}, // J
    {0x66,0x6C,0x78,0x70,0x78,0x6C,0x66,0x63,0x00,0x00,0x00,0x00}, // K
    {0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x7E,0x00,0x00,0x00,0x00}, // L
    {0x63,0x77,0x7F,0x6B,0x63,0x63,0x63,0x63,0x00,0x00,0x00,0x00}, // M
    {0x66,0x76,0x7E,0x7E,0x6E,0x66,0x66,0x66,0x00,0x00,0x00,0x00}, // N
    {0x3C,0x66,0x66,0x66,0x66,0x66,0x66,0x3C,0x00,0x00,0x00,0x00}, // O
    {0x7C,0x66,0x66,0x7C,0x60,0x60,0x60,0x60,0x00,0x00,0x00,0x00}, // P
    {0x3C,0x66,0x66,0x66,0x6A,0x6C,0x66,0x3B,0x00,0x00,0x00,0x00}, // Q
    {0x7C,0x66,0x66,0x7C,0x6C,0x66,0x66,0x63,0x00,0x00,0x00,0x00}, // R
    {0x3C,0x66,0x60,0x3C,0x06,0x06,0x66,0x3C,0x00,0x00,0x00,0x00}, // S
    {0x7E,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x00,0x00,0x00,0x00}, // T
    {0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x3C,0x00,0x00,0x00,0x00}, // U
    {0x66,0x66,0x66,0x66,0x66,0x66,0x3C,0x18,0x00,0x00,0x00,0x00}, // V
    {0x63,0x63,0x63,0x6B,0x7F,0x77,0x63,0x63,0x00,0x00,0x00,0x00}, // W
    {0x66,0x66,0x3C,0x18,0x3C,0x66,0x66,0x66,0x00,0x00,0x00,0x00}, // X
    {0x66,0x66,0x66,0x3C,0x18,0x18,0x18,0x18,0x00,0x00,0x00,0x00}, // Y
    {0x7E,0x06,0x0C,0x18,0x30,0x60,0x60,0x7E,0x00,0x00,0x00,0x00}, // Z
};

static int font_index(char c) {
    if (c >= 'a' && c <= 'z') c = c - 'a' + 'A'; // lowercase -> uppercase
    if (c < 0x20 || c > 'Z')  return 0;           // fallback to space
    return c - 0x20;
}

// =========================================================================
// Ticker buffer  —  circular buffer of captured characters for the banner
// =========================================================================
#define TICKER_MAX 128

typedef struct {
    char  buf[TICKER_MAX];
    int   head;   // index of oldest character
    int   count;  // number of valid characters
} Ticker;

extern Ticker ticker;

static void ticker_init(void) {
    ticker.head  = 0;
    ticker.count = 0;
}

static void ticker_push(char c) {
    int tail = (ticker.head + ticker.count) % TICKER_MAX;
    ticker.buf[tail] = c;
    if (ticker.count < TICKER_MAX)
        ticker.count++;
    else
        ticker.head = (ticker.head + 1) % TICKER_MAX; // overwrite oldest
}

static char ticker_get(int i) {
    return ticker.buf[(ticker.head + i) % TICKER_MAX];
}

// =========================================================================
// Low-level drawing primitives
// =========================================================================
static void fill_rect(int x, int y, int w, int h, uint16_t color) {
    int px, py;
    for (py = y; py < y + h; py++)
        for (px = x; px < x + w; px++)
            if (px >= 0 && px < FB_WIDTH && py >= 0 && py < FB_HEIGHT)
                write_pixel(py * FB_WIDTH + px, color);
}

static void draw_char(char c, int x, int y, int scale, uint16_t fg, uint16_t bg) {
    int idx = font_index(c);
    int row, col;
    for (row = 0; row < FONT_H; row++) {
        uint8_t bits = font8x12[idx][row];
        for (col = 0; col < FONT_W; col++) {
            uint16_t color = (bits & (0x80 >> col)) ? fg : bg;
            fill_rect(x + col * scale, y + row * scale, scale, scale, color);
        }
    }
}

static void draw_string(const char *s, int x, int y, int scale, uint16_t fg, uint16_t bg) {
    int cx = x;
    while (*s) {
        draw_char(*s, cx, y, scale, fg, bg);
        cx += FONT_W * scale + scale;
        s++;
    }
}

// =========================================================================
// VSync blanking wait  —  write pixels only during safe period
// =========================================================================
#define VSYNC_BASE CORE_2_VSYNC_BASE
#define HSYNC_BASE CORE_2_HSYNC_BASE

static void wait_for_blanking(void) {
    while (IORD_ALTERA_AVALON_PIO_DATA(VSYNC_BASE) != 0);
    while (IORD_ALTERA_AVALON_PIO_DATA(VSYNC_BASE) == 0);
}

// =========================================================================
// Scrolling banner  —  top BANNER_H pixels of screen in game mode
// Scrolls the ticker buffer continuously left to right.
// =========================================================================
#define BANNER_H      16
#define BANNER_SCALE  1
#define BANNER_SLOT_W (FONT_W * BANNER_SCALE + 2)
#define BANNER_FG     0xFD0   // warm yellow
#define BANNER_BG     0x112   // dark blue

extern int marquee_pixel_offset;
extern int banner_visible;

static void draw_banner_tick(void) {
	if (screen_busy || !banner_visible) return;

    if (ticker.count == 0) return;

    int total_width = ticker.count * BANNER_SLOT_W;
    int cy          = (BANNER_H - FONT_H * BANNER_SCALE) / 2 + 2;

	marquee_pixel_offset++;
	if (marquee_pixel_offset >= total_width + 4)
		marquee_pixel_offset = -(FB_WIDTH);

    int x;
    for (x = 0; x < FB_WIDTH; x++) {
        int string_x = x + marquee_pixel_offset - 4;

        if (string_x >= 0 && string_x < total_width) {
            int slot   = string_x / BANNER_SLOT_W;
            int char_x = string_x % BANNER_SLOT_W;

            if (slot < ticker.count && char_x < FONT_W * BANNER_SCALE) {
                int mask = (0x80 >> (char_x / BANNER_SCALE));
                int idx  = font_index(ticker_get(slot));
                int addr = cy * FB_WIDTH + x;
                int r;
                for (r = 0; r < FONT_H; r++) {
                    write_pixel(addr, (font8x12[idx][r] & mask) ? BANNER_FG : BANNER_BG);
                    addr += FB_WIDTH;
                }
                continue;
            }
        }

        // Background column
        int addr = cy * FB_WIDTH + x;
        int r;
        for (r = 0; r < FONT_H; r++) {
            write_pixel(addr, BANNER_BG);
            addr += FB_WIDTH;
        }
    }
}

#endif // VGA_GFX_H
